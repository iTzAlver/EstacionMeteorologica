# Keil uVision project Estacion.uvproj, settings and files
target MiniDK-2 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Estacion +hex
  c flags: Optim=1 wLevel=2
  c define: NO_RTX_KERNEL
  c include: ..\Startup;..\PWM;..\Principal;..\Setup;..\Menu;..\Menu\GLCD;..\Menu\Firmware\header;..\Menu\Firmware\source;..\Menu\Leds;..\Menu\TouchPanel;..\RTC;..\WDT;..\TCPIP;..\TCPIP\lib;C:\Keil\ARM\RV31\lib;..\TCPIP\FM\include;..\TCPIP\FM\source;..\Timers;..\Anemometro;..\FAT32;..\FAT32\FW\include;..\FAT32\FW\source;..\ADC;..\DAC;..\BaseDeDatos;..\OneWire;..\DEBUG;..\UART;..\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group README
    ../: README.md
  group WDT
    ../WDT/: WDT.c
  group ANEMOMETRO
    ../ANEMOMETRO/: Anemometro.c
  group PWM
    ../PWM/: PWM.c
  group RTC
    ../RTC/: RTC.c
  group TCP/IP
    ../TCPIP/: HTTP_SOURCE.c HTTP_CGI.c index.cgi WEB.inp WEB.C
    ../TCPIP/config/: Net_Config.c EMAC_LPC17xx_LAN8720.c
    ../TCPIP/lib/: TCP_CM3.lib
  group Menu
    ../Menu/: Statechart.c
    ../Menu/TouchPanel/: TouchPanel.c
  group Principal
    ../Principal/: main.c
  group Startup
    ./: startup_LPC17xx.s
    ../Startup/: core_cm3.c system_LPC17xx.c
  group Setup
    ../Setup/: configura.c
  group Timers
    ../Timers/: Timers.c
  group OneWire
    ../OneWire/: OneWire.c OneWirev2.c
  group ADC
    ../ADC/: Ldr.c uFono.c UVA30A.c
  group DAC
    ../DAC/: DAC.c
  group DATABASE
    ../BaseDeDatos/: LUT.c DMA.c
  group SDCARD
    ../FAT32/FW/source/: diskio.c ff.c SPI_MSD_Driver.c
  group DEBUG
    ../DEBUG/: DEBUG.c
  group CMSIS
    ../Menu/Firmware/source/: lpc17xx_ssp.c lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c
  group GLCD
    ../Menu/GLCD/: AsciiLib.c GLCD.c
  group HEADERS
    ../PWM/: PWM.h
    ../Menu/: Statechart.h menu.h
    ../Menu/TouchPanel/: TouchPanel.h
    ../Menu/Leds/: leds.h
    ../Menu/GLCD/: GLCD.h AsciiLib.h
    ../Principal/: header.h Systemsymbols.h
    ../RTC/: RTC.h
    ../Setup/: configura.h
    ../WDT/: WDT.h
    ../TCPIP/lib/: HTTP_SOURCE.h HTTP_CGI.h miGlobal.h
    ../ANEMOMETRO/: Anemometro.h
    ../Timers/: Timers.h
    ../ADC/: Ldr.h uFono.h UVA30A.h
    ../DAC/: DAC.h
    ../UART/: UART0.h
  group UART_PC
    ../UART/: UART0.c UART3.c uart.c
  group I2C
    ../I2C/: I2C.c I2Clib.c
